# Keil uVision project project.uvprojx, settings and files
target Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429BI STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,ARM_MATH_CM4,__FPU_PRESENT
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User\bsp\inc;..\..\User\bsp;..\..\User;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\User\fonts;..\..\emWin\GUI_X;..\..\emWin\Config;..\..\emWin\Include;..\..\emWin\emWinTask;..\..\User\fatfs\src;..\..\emWin\STemWin_Addons;..\..\emWin\HanZi;..\..\Libraries\STM32F10x_DSP_Lib\inc;..\..\User\mp3\pub;..\..\User\mp3\real;..\..\User\malloc;..\..\User\libapp;..\..\User\CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/: main.c includes.h SysInfoTest.c FreeRTOSConfig.h
  group AppLib
    ../../User/libapp/: app_user_lib.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32f4xx_it.c stm32f4xx_assert.c
    ../../User/bsp/src/: bsp_led.c bsp_key.c bsp_adc.c bsp_dwt.c bsp_ext_io.c bsp_sdio_sd.c bsp_adc_dso.c bsp_dac_wave.c bsp_uart_fifo.c bsp_tim_pwm.c bsp_i2c_gpio.c bsp_fmc_sdram.c bsp_eeprom_24xx.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_usart.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_fmc.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_ltdc.c stm32f4xx_sdio.c stm32f4xx_exti.c stm32f4xx_pwr.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_adc.c stm32f4xx_dac.c
  group CMSIS
    ../../User/bsp/: system_stm32f4xx.c
  group fonts
    ../../User/fonts/: asc12.c asc16.c fonts.h hz12.c hz16.c hz24.c hz32.c song16.c NI7SEG90.c ra8875_asc_width.c
  group LCD_Driver
    ../../User/bsp/src/: param.c bsp_gt811.c bsp_tft_429.c bsp_tft_lcd.c bsp_touch.c bsp_ts_ft5x06.c TOUCH_STMPE811.c
  group GUI_X
    ../../emWin/GUI_X/: GUI_X_FreeRTOS.c
  group GUI/Config
    ../../emWin/Config/: GUIConf.h GUIConf.c LCDConf_Lin_Template.c LCDConf_Lin_Template.h
  group GUI/DEMO
    ../../emWin/emWinTask/: MainTask.c MainTask.h DSO_Init.c DSO_DrawCursorH.c DSO_DrawCursorV.c DSO_DrawBakFrame.c DSO_AmplitudeDlg.c DSO_Status1Dlg.c DSO_Status2Dlg.c DSO_ScaleDlg.c DSO_SysInfoDlg.c DSO_MeasureDlg.c DSO_AdcDlg.c DSO_DacDlg.c DSO_MathDlg.c DSO_SettingDlg.c DSO_MultiMeter.c DSO_WaveProcess.c DSO_FirFilter_Step1KHz.c DSO_FirFilter_Step10KHz.c DSO_FirFilter_Step100KHz.c
  group GUI/ICON
    ../../emWin/ICON/: Return.c Settings.c
  group GUI/Lib
    ../../emWin/STemWin_Addons/: ST_GUI_Addons.h STemWin_Addons_KEIL.lib
    ../../emWin/GUILib/: STemWin532_CM4_OS_Keil_ot.lib
  group DSP/Lib
    ../../Libraries/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group FreeRTOS/Source
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Ports
    ../../FreeRTOS/portable/MemMang/: heap_4.c
    ../../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
  group FreeRTOS/CPU
    ../../User/CPU/: cpu_utils.c cpu_utils.h
  group FatFS
    ../../User/fatfs/src/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
  group Malloc
    ../../User/malloc/: rt_Memory.c rt_Memory.h rt_TypeDef.h
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt 03.例程操作说明.txt
